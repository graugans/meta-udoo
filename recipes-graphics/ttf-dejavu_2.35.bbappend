FILESEXTRAPATHS_prepend := "${THISDIR}/ttf-fonts:"
